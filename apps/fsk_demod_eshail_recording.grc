<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>2400</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>-721733</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1800e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(samp_rate/baud)</value></param>
</block>
<block>
<key>aausat_aausat4_beacon_parser</key>
<param><key>id</key><value>aausat_aausat4_beacon_parser_0</value></param>
</block>
<block>
<key>aausat_aausat4_fec</key>
<param><key>id</key><value>aausat_aausat4_fec_0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*fsk_deviation_hz/8.0)</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/satlab/eshail_test/recordings/gqrx_20190406_210443_740300600_1800000_fc.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>sps*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>[(0.0008982152212411165-0j), (0.0008993237279355526+0j), (0.0009023502934724092+0j), (0.0009072949178516865+0j), (0.0009141568443737924+0j), (0.0009229343268088996+0j), (0.0009336250368505716+0j), (0.0009462261805310845+0j), (0.0009607337415218353+0j), (0.0009771434124559164+0j), (0.0009954500710591674+0j), (0.0010156475473195314+0j), (0.001037729438394308+0j), (0.0010616881772875786+0j), (0.0010875160805881023+0j), (0.001115203951485455+0j), (0.001144742825999856+0j), (0.0011761219939216971+0j), (0.001209330977872014+0j), (0.0012443580199033022+0j), (0.0012811908964067698+0j), (0.0013198168016970158+0j), (0.0013602219987660646+0j), (0.0014023920521140099+0j), (0.0014463122934103012+0j), (0.0014919668901711702+0j), (0.001539339660666883+0j), (0.0015884137246757746+0j), (0.0016391711542382836+0j), (0.0016915940213948488+0j), (0.0017456632340326905+0j), (0.0018013594672083855+0j), (0.0018586628139019012+0j), (0.0019175520865246654+0j), (0.0019780059810727835+0j), (0.002040002727881074+0j), (0.002103520091623068+0j), (0.002168534556403756+0j), (0.0022350226063281298+0j), (0.002302959794178605+0j), (0.0023723216727375984+0j), (0.002443082630634308+0j), (0.002515216823667288+0j), (0.0025886984076350927+0j), (0.002663499442860484+0j), (0.002739593153819442+0j), (0.0028169516008347273+0j), (0.002895546378567815+0j), (0.0029753483831882477+0j), (0.0030563282780349255+0j), (0.0031384567264467478+0j), (0.0032217027619481087+0j), (0.0033060365822166204+0j), (0.003391426522284746+0j), (0.003477840917184949+0j), (0.003565248567610979+0j), (0.0036536166444420815+0j), (0.003742912784218788+0j), (0.0038331039249897003+0j), (0.003924156539142132+0j), (0.0040160370990633965+0j), (0.0041087111458182335+0j), (0.004202145617455244+0j), (0.0042963046580553055+0j), (0.004391154274344444+0j), (0.004486658610403538+0j), (0.0045827822759747505+0j), (0.0046794903464615345+0j), (0.004776745568960905+0j), (0.0048745134845376015+0j), (0.004972756840288639+0j), (0.005071439314633608+0j), (0.005170523654669523+0j), (0.005269974935799837+0j), (0.005369753576815128+0j), (0.005469824653118849+0j), (0.005570149980485439+0j), (0.005670691840350628+0j), (0.005771413445472717+0j), (0.005872277542948723+0j), (0.005973245017230511+0j), (0.006074280943721533+0j), (0.006175345741212368+0j), (0.006276401691138744+0j), (0.00637741107493639+0j), (0.006478338502347469+0j), (0.006579143460839987+0j), (0.006679789163172245+0j), (0.006780239287763834+0j), (0.00688045471906662+0j), (0.00698039960116148+0j), (0.007080035284161568+0j), (0.007179325446486473+0j), (0.007278231903910637+0j), (0.007376719731837511+0j), (0.007474750746041536+0j), (0.007572287693619728+0j), (0.007669295649975538+0j), (0.007765736896544695+0j), (0.007861576974391937+0j), (0.007956779561936855+0j), (0.008051307871937752+0j), (0.008145127445459366+0j), (0.008238203823566437+0j), (0.008330500684678555+0j), (0.008421985432505608+0j), (0.00851262267678976+0j), (0.008602377958595753+0j), (0.008691218681633472+0j), (0.008779111318290234+0j), (0.00886602234095335+0j), (0.00895192101597786+0j), (0.009036773815751076+0j), (0.009120548143982887+0j), (0.009203214198350906+0j), (0.009284740313887596+0j), (0.009365096688270569+0j), (0.009444251656532288+0j), (0.009522177278995514+0j), (0.009598842822015285+0j), (0.009674221277236938+0j), (0.009748282842338085+0j), (0.009821001440286636+0j), (0.009892348200082779+0j), (0.009962297044694424+0j), (0.010030820965766907+0j), (0.010097895748913288+0j), (0.010163495317101479+0j), (0.010227595455944538+0j), (0.010290171951055527+0j), (0.010351200588047504+0j), (0.010410659946501255+0j), (0.010468526743352413+0j), (0.010524780489504337+0j), (0.010579396970570087+0j), (0.01063235942274332+0j), (0.01068364642560482+0j), (0.010733239352703094+0j), (0.010781116783618927+0j), (0.010827265679836273+0j), (0.010871664620935917+0j), (0.010914298705756664+0j), (0.010955150239169598+0j), (0.010994207113981247+0j), (0.01103145256638527+0j), (0.011066872626543045+0j), (0.011100453324615955+0j), (0.01113218441605568+0j), (0.011162052862346172+0j), (0.011190044693648815+0j), (0.011216153390705585+0j), (0.011240368708968163+0j), (0.011262677609920502+0j), (0.01128307729959488+0j), (0.0113015566021204+0j), (0.011318109929561615+0j), (0.011332729831337929+0j), (0.011345410719513893+0j), (0.01135614886879921+0j), (0.011364941485226154+0j), (0.01137178298085928+0j), (0.011376671493053436+0j), (0.01137960609048605+0j), (0.011380583979189396+0j), (0.01137960609048605+0j), (0.011376671493053436+0j), (0.01137178298085928+0j), (0.011364941485226154+0j), (0.01135614886879921+0j), (0.011345410719513893+0j), (0.011332729831337929+0j), (0.011318109929561615+0j), (0.0113015566021204+0j), (0.01128307729959488+0j), (0.011262677609920502+0j), (0.011240368708968163+0j), (0.011216153390705585+0j), (0.011190044693648815+0j), (0.011162052862346172+0j), (0.01113218441605568+0j), (0.011100453324615955+0j), (0.011066872626543045+0j), (0.01103145256638527+0j), (0.010994207113981247+0j), (0.010955150239169598+0j), (0.010914298705756664+0j), (0.010871664620935917+0j), (0.010827265679836273+0j), (0.010781116783618927+0j), (0.010733239352703094+0j), (0.01068364642560482+0j), (0.01063235942274332+0j), (0.010579396970570087+0j), (0.010524780489504337+0j), (0.010468526743352413+0j), (0.010410659946501255+0j), (0.010351200588047504+0j), (0.010290171951055527+0j), (0.010227595455944538+0j), (0.010163495317101479+0j), (0.010097895748913288+0j), (0.010030820965766907+0j), (0.009962297044694424+0j), (0.009892348200082779+0j), (0.009821001440286636+0j), (0.009748282842338085+0j), (0.009674221277236938+0j), (0.009598842822015285+0j), (0.009522177278995514+0j), (0.009444251656532288+0j), (0.009365096688270569+0j), (0.009284740313887596+0j), (0.009203214198350906+0j), (0.009120548143982887+0j), (0.009036773815751076+0j), (0.00895192101597786+0j), (0.00886602234095335+0j), (0.008779111318290234+0j), (0.008691218681633472+0j), (0.008602377958595753+0j), (0.00851262267678976+0j), (0.008421985432505608+0j), (0.008330500684678555+0j), (0.008238203823566437+0j), (0.008145127445459366+0j), (0.008051307871937752+0j), (0.007956779561936855+0j), (0.007861576974391937+0j), (0.007765736896544695+0j), (0.007669295649975538+0j), (0.007572287693619728+0j), (0.007474750746041536+0j), (0.007376719731837511+0j), (0.007278231903910637+0j), (0.007179325446486473+0j), (0.007080035284161568+0j), (0.00698039960116148+0j), (0.00688045471906662+0j), (0.006780239287763834+0j), (0.006679789163172245+0j), (0.006579143460839987+0j), (0.006478338502347469+0j), (0.00637741107493639+0j), (0.006276401691138744+0j), (0.006175345741212368+0j), (0.006074280943721533+0j), (0.005973245017230511+0j), (0.005872277542948723+0j), (0.005771413445472717+0j), (0.005670691840350628+0j), (0.005570149980485439+0j), (0.005469824653118849+0j), (0.005369753576815128+0j), (0.005269974935799837+0j), (0.005170523654669523+0j), (0.005071439314633608+0j), (0.004972756840288639+0j), (0.0048745134845376015+0j), (0.004776745568960905+0j), (0.0046794903464615345+0j), (0.0045827822759747505+0j), (0.004486658610403538+0j), (0.004391154274344444+0j), (0.0042963046580553055+0j), (0.004202145617455244+0j), (0.0041087111458182335+0j), (0.0040160370990633965+0j), (0.003924156539142132+0j), (0.0038331039249897003+0j), (0.003742912784218788+0j), (0.0036536166444420815+0j), (0.003565248567610979+0j), (0.003477840917184949+0j), (0.003391426522284746+0j), (0.0033060365822166204+0j), (0.0032217027619481087+0j), (0.0031384567264467478+0j), (0.0030563282780349255+0j), (0.0029753483831882477+0j), (0.002895546378567815+0j), (0.0028169516008347273+0j), (0.002739593153819442+0j), (0.002663499442860484+0j), (0.0025886984076350927+0j), (0.002515216823667288+0j), (0.002443082630634308+0j), (0.0023723216727375984+0j), (0.002302959794178605+0j), (0.0022350226063281298+0j), (0.002168534556403756+0j), (0.002103520091623068+0j), (0.002040002727881074+0j), (0.0019780059810727835+0j), (0.0019175520865246654+0j), (0.0018586628139019012+0j), (0.0018013594672083855+0j), (0.0017456632340326905+0j), (0.0016915940213948488+0j), (0.0016391711542382836+0j), (0.0015884137246757746+0j), (0.001539339660666883+0j), (0.0014919668901711702+0j), (0.0014463122934103012+0j), (0.0014023920521140099+0j), (0.0013602219987660646+0j), (0.0013198168016970158+0j), (0.0012811908964067698+0j), (0.0012443580199033022+0j), (0.001209330977872014+0j), (0.0011761219939216971+0j), (0.001144742825999856+0j), (0.001115203951485455+0j), (0.0010875160805881023+0j), (0.0010616881772875786+0j), (0.001037729438394308+0j), (0.0010156475473195314+0j), (0.0009954500710591674+0j), (0.0009771434124559164+0j), (0.0009607337415218353+0j), (0.0009462261805310845+0j), (0.0009336250368505716+0j), (0.0009229343268088996+0j), (0.0009141568443737924+0j), (0.0009072949178516865+0j), (0.0009023502934724092+0j), (0.0008993237279355526+0j), (0.0008982152212411165+0j)]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>2e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>0.2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>32000</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-60</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1/500</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>sync_to_pdu_packed</key>
<param><key>id</key><value>sync_to_pdu_packed_0</value></param>
<param><key>packlen</key><value>200</value></param>
<param><key>threshold</key><value>3</value></param>
<param><key>sync</key><value>"010011110101101000110000010000010100010101001011"</value></param>
</block>
<connection><source_block_id>aausat_aausat4_fec_0</source_block_id><sink_block_id>aausat_aausat4_beacon_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>aausat_aausat4_fec_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>sync_to_pdu_packed_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_to_pdu_packed_0</source_block_id><sink_block_id>aausat_aausat4_fec_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
